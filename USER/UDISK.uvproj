# Keil uVision project UDISK.uvproj, settings and files
target UDISK (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UDISK +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\FWLIB\inc;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/ETHERNET/: lan8720.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c usbusr.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
